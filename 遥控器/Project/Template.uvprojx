# Keil uVision project Template.uvprojx, settings and files
target Target (ARM-ADS)
  device: STM32F429VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,__cplusplus
  c misc: --cpp11
  c include: ..\USER;..\FWLib\CMSIS\Include;..\FWLib\STM32F4xx_StdPeriph_Driver\inc;..\FWLib\CMSIS\Device;..\Drivers\inc;..\Control\inc;..\MathSupport\inc;..\DSS\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../FWLib/CMSIS/Device/STARTUP/: startup_stm32f429_439xx.s
  group USER
    ../USER/: main.c stm32f4xx_it.c
  group CMSIS
    ../FWLib/CMSIS/Device/: system_stm32f4xx.c
  group STDLib
    ../FWLib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Drivers
    ../Drivers/src/: TIMs.c USART.c Map.c Beep.c WatchDog.c InterfaceToEquips.c InterfaceToMaster.c interfaceToMicroPC.c Control.c
  group MathSupport
    ../MathSupport/src/: PID.c PlaneAnalyticGeometry.c Matrix.cpp SolveSystem.cpp
  group Control
    ../Drivers/src/: InterfaceToF103.c
    ../Control/src/: Vol_curve.c PositionCtrl.c Motion_Ctrl.c ActionCtrl.c
  group DSS
    ../DSS/src/: Base.c Process.c Schedule.c
    ../DSS/: readme.txt
  group DOC
    ../Doc/: readme.txt
